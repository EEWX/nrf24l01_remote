# IAR project JBCSTM8L151.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C6 STM8L151C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: STM8L15x_StdPeriph_Driver\inc; AtomOS1.3\kernel; AtomOS1.3\ports\stm8; User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: JBCSTM8L151.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group AtomOS
    AtomOS1.3/kernel/: atomkernel.c atommutex.c atomqueue.c atomsem.c atomtimer.c
    AtomOS1.3/ports/stm8/: atomport-asm-iar.s
  group Lib
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User
    User/: adc.c encoder.c Joystick.c lcd19264.c nrf24l01.c PPM.c stm8l15x_it.c system.c ui.c
    AtomOS1.3/ports/stm8/: atomport.c tests-main.c uart.c
